# Keil uVision project nixie_clock.uvprojx, settings and files
target LPC812 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC812M101JD20 NXP
  pack: NXP.LPC812_DFP.12.0.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nixie_clock
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\NXP LPCopen\software\lpc_core\lpc_chip\chip_common;..\NXP LPCopen\software\lpc_core\lpc_chip\chip_8xx;..\NXP LPCopen\software\lpc_core\lpc_chip\chip_8xx\config
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Lib
    ../NXP LPCopen/software/lpc_core/lpc_chip/chip_8xx/keil_output/chip_8xx_lib/: chip_8xx_lib.lib
  group nixie_core
    ./: nixie.c
  group driver_functions
    ./: driver.c driver.h uart.c uart.h
target LPC812_BOARD_REV1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC812M101JD20 NXP
  pack: NXP.LPC812_DFP.12.0.0
  cpu: IRAM(0x10000000,0x00001000) IROM(0x00000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nixie_clock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -DBOARD_REV1=,
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
software components: CMSIS:CORE 5.2.0, Device:Startup 2.0.0, Device:Startup:LPC812_startup 1.0.0
